File: kicad/peripheral.kicad_sch (KiCad schematic)
At the start: 6 parts, among them U40 8255A

Commit message: made updates for rev2
Other:
- moved on the sheet: C61, C62, DS2, R41, U40, VR1
